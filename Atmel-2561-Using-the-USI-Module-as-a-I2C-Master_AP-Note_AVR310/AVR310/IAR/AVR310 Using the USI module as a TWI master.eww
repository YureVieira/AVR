<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AVR310 Using the USI module as a TWI master.ewp</path>
  </project>
  <batchBuild/>
</workspace>


